# Keil uVision project TCP_Cam.uvprojx, settings and files
target TCP_Cam (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: TCP_Cam +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Output/TCP_Cam.bin ./TCP_Cam/TCP_Cam.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../../Core/Inc;../../FATFS/Target;../../FATFS/App;../../Drivers/STM32F4xx_HAL_Driver/Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../Middlewares/Third_Party/FreeRTOS/Source/include;../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../Middlewares/Third_Party/FatFs/src;../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/CMSIS/Include;../../Peripheral/RTL8720DN;../../Common;../../cm_backtrace;../../cm_backtrace/Languages/zh-CN;../../cm_backtrace/Languages/en-US;../../cm_backtrace/fault_handler/keil
  asm include: ../../Core/Inc;../../FATFS/Target;../../FATFS/App;../../Drivers/STM32F4xx_HAL_Driver/Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../Middlewares/Third_Party/FreeRTOS/Source/include;../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../Middlewares/Third_Party/FatFs/src;../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  memory RVCT10: RAM 0x200c0000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c iwdg.c rtc.c sdio.c spi.c tim.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../../FATFS/App/: fatfs.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Peripheral/RTL8720DN
    ../../Peripheral/RTL8720DN/: wifi_api.c wifi_at.c wifi_data.c
  group Common
    ../../Common/: cz_log.c cz_sysInfo.c public.h
  group cm_backtrace
    ../../cm_backtrace/: cm_backtrace.c cmb_cfg.h cmb_def.h
    ../../cm_backtrace/fault_handler/keil/: cmb_fault.S
    ../../cm_backtrace/Languages/en-US/: cmb_en_US.h
software components: CMSIS:CORE 4.3.0
